# Repository OLIMEX/RK3328-SOM-EBV

File README.md:

# RK3328-SOM-EVB
Evaluation board for RK3328-SOM System on modules

Product page: https://www.olimex.com/Products/SOM/RK3328/RK3328-EVB/

## License
* Hardware is released under CERN OHL v1.2 license
* Software is released under GPL3 License
* Documentation is released under CC BY-SA 3.0

## KiCad design HARDWARE/RK3328-SOM-EVB_Rev-A/RK3328-SOM-EVB_Rev_A.kicad_pcb

Board: 4 copper layers, 99.1 x 78.7 mm, 146 parts (1 on the bottom side), 164 nets.

Parts:
C1, C2, C9, C14, C15, C17, C18, C20, C23, C27, C28, C29, C30, C31, C37: 100nF/10V/10%/X7R/C0402; C_0402_5MIL_DWS
C3, C4, C5, C6: NA(47uF/6.3V/20%/X5R/C0805); C_0805_5MIL_DWS
C7, C8, C10, C11, C12, C13, C19, C25, C38, C39: 47uF/6.3V/20%/X5R/C0805; C_0805_5MIL_DWS
C16, C36: 1nF/2kV/10%/X7R/C1206; C_1206_5MIL_DWS_ISO
C21, C22, C26, C34, C35: 22uF/6.3V/20%/X5R/C0603; C_0603_5MIL_DWS
C24: 1uF/10V/10%/X5R/C0603; C_0603_5MIL_DWS
C32, C33: 33pF/50V/5%/COG/C0402; C_0402_5MIL_DWS
D1: 1N4007\SMA; SMA-KA
D2: 1N5819S4/SOD123; SOD-123_1C-2A_KA
D3: SMBJ6.0A; DO214AA_1(K)-2(A)
D4: 1N5822/SS34/SMA; SMA-KA
EXT1: BH26S
FET1: BSS138(SOT23-3); SOT23
FET2: IRLML6402(SOT-23); SOT23
FID1, FID2, FID3: Fiducial; Fiducial1x3
FUSE1: FSMD035; FUSE-1206
FUSE2: NA(5025); FUSE-5025
Flash_Con1: Flash_Con[DF12(3.0)-40DS-0.5V(86)]
GPIO1, GPIO2: PA-V16X-2X20-LF; GPH127SMT-02X20(PA-V16X-2X20-LF)
GPIO3, GPIO4: PA-V16X-2X10-LF; GPH127SMT-02X10(PA-V16X-2X10-LF)
HDMI1: HDMI-SWM-19; HDMI-SWM-19-TEST
L1, L2, L3, L4, L5, L6: FB0805/600R/2A; L_0805_5MIL_DWS
LAN1: TM211Q01FM22
LAN2: RJLD-060TC1(LPJ4013EDNL); RJLBC-060TC1
MH1, MH2, MH3, MH4, MH5, MH6, MH7, MH8: Mounting_Hole_NPTH; Mounting_Hole_Drill-3.3mm_Clerance-7mm
MICRO_SD1: MICRO_SD(TFC-WPAPR-08); TFC-WPAPR-08
Olimex logo: OLIMEX_LOGO_TB
PWR1: T1107A(6x3,8x2,5MM)
PWRLED1: LED/Red/0603; LED_0603_KA
PWR_J1: PWRJ-2mm(YDJ-1134)
Q1: Q25MHz/20pF/20ppm/2P/5x3.2mm; HCX-4S_2Pins_5.0x3.2mm_TEST
R1: 27k/R0402; R_0402_5MIL_DWS
R2, R3, R42: 2.2k/R0402; R_0402_5MIL_DWS
R4, R7, R10, R14: 4.7k/R0402; R_0402_5MIL_DWS
R5, R6, R8, R11, R12, R15, R19, R33, R37, R39, R41: 10k/R0402; R_0402_5MIL_DWS
R9: 13k/1%/R0402; R_0402_5MIL_DWS
R13: NA(10k/R0402); R_0402_5MIL_DWS
R16, R22, R24, R25, R26, R27, R28, R30: 1k/R0402; R_0402_5MIL_DWS
R17, R18, R20, R21, R23, R40: 22R/R0402; R_0402_5MIL_DWS
R29, R38: 100k/R0402; R_0402_5MIL_DWS
R31: NA/R0402; R_0402_5MIL_DWS
R32: 12.1k/1%/R0603; R_0603_5MIL_DWS
R34: 120R/R0603; R_0603_5MIL_DWS
R35, R36: 330R/R0402; R_0402_5MIL_DWS
RM1: RA0805_(4X0402)_4.7k; RA0805_(4X0402)_xx_BIGGEROUTPADS
RM2, RM3: RA0805_(4X0402)_22R; RA0805_(4X0402)_xx_BIGGEROUTPADS
RM4: RA1206_(4x0603)_4B8_100k; RA1206_(4X0603)_4B8_xx
RST1: T1107A(6x3,8x2,5MM)
Sign_Antistatic: Val**; LOGO_ANTISTATIC_1
Sign_OSHW: LOGO_OPENHARDWARE_8x8
Sign_PB-Free: LOGO_PBFREE
Sign_RecycleBin: LOGO_RECYCLEBIN_1
Sign_RoHS: Val**; LOGO_ROHS_1
U1, U2, U3: NA(RCLAMP0524P(SLP2510P8)); SLP2510P8_TEST
U4, U5, U8: SY6280AAC(SOT23-5); SOT-23-5
U6, U7: NA(ESD5304D-10/TR); SLP2510P8_TEST
U9: KSZ9031RNXCC(QFN48_1DRILL(PADPITCH-0.5MM)); QFN48_1DRILL(PADPITCH-0.5MM)
UART_DBG1: HN1x3
UEXT1: BH10S
USB3.0_TYPE-A1: USB-SWZ1BL-9A-LF; USB3.0-TypeA(USB-SWZ1BL-9A-LF)
USB-HOST1: USB_A_VERTICAL; USB_A_VERTICAL_PTH
USB-OTG1: MICRO_USB\MISB-SWMM-5B_LF; USB-MICRO_MISB-SWMM-5B_LF
VR1: AMS1117(ADJ); SOT223

Connections:
+3V3: D1.2, EXT1.1, FET1.1, Flash_Con1.1, Flash_Con1.3, GPIO2.1, GPIO2.3, L3.2, L6.1, R1.2, R6.1, R13.1, R37.1, R38.2, R39.2, RM4.1.1, RM4.2.1, RM4.3.1, RM4.4.1, UEXT1.1
+5V: C10.1, C11.1, C13.2, D4.1, FET2.2, FUSE1.1, GPIO1.1, GPIO1.3, GPIO1.5, GPIO1.7, R2.2, R3.2, R42.1, U4.5, U5.5, U8.5
+5V_EXT: C39.2, D3.1, D4.2, FET2.1, FUSE2.1, FUSE2.2, PWR_J1.+, R41.1
+5V_USBOTG: C2.2, FET2.3, L1.1, USB-OTG1.1
/1.25_EXT: C35.1, L4.2, L5.2, R34.1, VR1.2
/DBG_UART2-RxD: D2.2, GPIO2.25, R37.2
/DBG_UART2-TxD: GPIO2.27, UART_DBG1.1
/FEPHY_LED_DATA_M1: GPIO2.15, LAN2.AY1
/FEPHY_LED_LINK_M1: GPIO2.17, LAN2.AG1
/FEPHY_PWFBOUT: C37.1, GPIO2.9, LAN2.3, LAN2.6
/FEPHY_RX_N: GPIO2.5, LAN2.8
/FEPHY_RX_P: GPIO2.7, LAN2.7
/FEPHY_TX_N: GPIO2.11, LAN2.2
/FEPHY_TX_P: GPIO2.13, LAN2.1
/GMAC_CLKIN: GPIO2.34, R23.1
/GMAC_MDC: GPIO2.30, U9.36
/GMAC_MDIO: GPIO2.32, R16.1, U9.37
/GMAC_RXCLK: GPIO2.28, R17.1
/GMAC_RXCTL: GPIO2.26, R18.1
/GMAC_RXD0: GPIO2.24, RM2.1.2
/GMAC_RXD1: GPIO2.22, RM2.2.2
/GMAC_RXD2: GPIO2.20, RM2.3.2
/GMAC_RXD3: GPIO2.18, RM2.4.2
/GMAC_TXCLK: GPIO2.14, R20.1
/GMAC_TXCTL: GPIO2.16, R21.1
/GMAC_TXD0: GPIO2.6, RM3.4.2
/GMAC_TXD1: GPIO2.8, RM3.3.2
/GMAC_TXD2: GPIO2.10, RM3.2.2
/GMAC_TXD3: GPIO2.12, RM3.1.2
/GPIO1_C2\EPHY-RST#: GPIO2.36, R30.2
/GPIO1_D0: EXT1.3, GPIO2.19
/GPIO1_D2: EXT1.5, GPIO2.21
/GPIO1_D4: EXT1.7, GPIO2.23
/HCEC: FET1.2, GPIO1.26, R1.1, U3.1, U3.10
/HHPD: GPIO1.32, R4.2, R5.2, U3.5, U3.6
/HSCL: GPIO1.28, HDMI1.15, R2.1, U3.2, U3.9
/HSDA: GPIO1.30, HDMI1.16, R3.1, U3.4, U3.7
/HTX0N: GPIO1.20, HDMI1.9, U2.2, U2.9
/HTX0P: GPIO1.18, HDMI1.7, U2.1, U2.10
/HTX1N: GPIO1.16, HDMI1.6, U1.5, U1.6
/HTX1P: GPIO1.14, HDMI1.4, U1.4, U1.7
/HTX2N: GPIO1.12, HDMI1.3, U1.2, U1.9
/HTX2P: GPIO1.10, HDMI1.1, U1.1, U1.10
/HTXCN: GPIO1.24, HDMI1.12, U2.5, U2.6
/HTXCP: GPIO1.22, HDMI1.10, U2.4, U2.7
/IR_RX: EXT1.24, GPIO2.37
/MDI[0]+: LAN1.1, U9.2
/MDI[0]-: LAN1.2, U9.3
/MDI[1]+: LAN1.3, U9.5
/MDI[1]-: LAN1.4, U9.6
/MDI[2]+: LAN1.7, U9.7
/MDI[2]-: LAN1.8, U9.8
/MDI[3]+: LAN1.9, U9.10
/MDI[3]-: LAN1.10, U9.11
/PHYAD0: LAN1.14, R26.1
/PHYAD1: LAN1.12, R27.1
/PWM2: EXT1.25, GPIO2.35
/SARADC_IN0: EXT1.4, GPIO4.17
/SARADC_IN1: EXT1.6, GPIO4.19
/SDMMC0_CK: GPIO4.16, R40.2
/SDMMC0_CMD: GPIO4.18, MICRO_SD1.3, R39.1
/SDMMC0_D0: GPIO4.8, MICRO_SD1.7, RM4.2.2
/SDMMC0_D1: GPIO4.10, MICRO_SD1.8, RM4.3.2
/SDMMC0_D2: GPIO4.12, MICRO_SD1.1, RM4.1.2
/SDMMC0_D3: GPIO4.14, MICRO_SD1.2, R38.1
/SDMMC0_DET: GPIO4.20, MICRO_SD1.9, RM4.4.2
/SH_Gigabit-ETH: C16.2, LAN1.SH1, LAN1.SH2
/SH_Megabit-ETH: C36.1, LAN2.GND1, LAN2.GND2
/SPDIF_TX_M0: EXT1.26, GPIO2.33
/SPI_CLK_M2: Flash_Con1.15, GPIO3.12, UEXT1.9
/SPI_CSN0_M2: Flash_Con1.27, GPIO3.18
/SPI_CSN1_M0: GPIO3.20, UEXT1.10
/SPI_RXD_M2: Flash_Con1.25, GPIO3.16, UEXT1.7
/SPI_TXD_M2: Flash_Con1.19, GPIO3.14, UEXT1.8
/USB0-DRV: GPIO1.17, R11.2, U4.4
/USB0-D_N: GPIO1.11, USB-OTG1.2
/USB0-D_P: GPIO1.13, USB-OTG1.3
/USB0-ID: GPIO1.15, R6.2, USB-OTG1.4
/USB0-VBUSDET: C9.2, GPIO1.9, R7.1, R8.2
/USB1-DRV: GPIO1.23, R12.2, R13.2, U5.4
/USB1-D_N: GPIO1.19, USB-HOST1.2
/USB1-D_P: GPIO1.21, USB-HOST1.3
/USB30-VBUSDET: C12.2, GPIO1.37, U8.1, USB3.0_TYPE-A1.1
/USB30_DRV: GPIO1.39, R15.2, U8.4
/USB30_D_N: GPIO1.35, U6.1, U6.10, USB3.0_TYPE-A1.2
/USB30_D_P: GPIO1.33, U6.2, U6.9, USB3.0_TYPE-A1.3
/USB30_RX_N: GPIO1.27, U6.5, U6.6, USB3.0_TYPE-A1.5
/USB30_RX_P: GPIO1.25, U6.4, U6.7, USB3.0_TYPE-A1.6
/USB30_TX_N: GPIO1.31, U7.4, U7.7, USB3.0_TYPE-A1.8
/USB30_TX_P: GPIO1.29, U7.5, U7.6, USB3.0_TYPE-A1.9
/VDD33: C17.1, C19.2, C20.1, C25.2, C28.1, L3.1, LAN1.11, LAN1.13, R16.2, R19.1, R24.1, R25.1, R29.2, R33.2, RM1.1.1, RM1.2.1, RM1.3.1, RM1.4.1, U9.1, U9.12, U9.16, U9.34, U9.40
/eMMC_CLK: Flash_Con1.4, GPIO3.6
/eMMC_CMD: Flash_Con1.9, GPIO3.8
/eMMC_D0: Flash_Con1.40, GPIO3.19
/eMMC_D1: Flash_Con1.36, GPIO3.17
/eMMC_D2: Flash_Con1.32, GPIO3.15
/eMMC_D3: Flash_Con1.28, GPIO3.13
/eMMC_D4: Flash_Con1.24, GPIO3.11
/eMMC_D5: Flash_Con1.20, GPIO3.9
/eMMC_D6: Flash_Con1.16, GPIO3.7
/eMMC_D7: Flash_Con1.12, GPIO3.5
/eMMC_RST: Flash_Con1.11, GPIO3.10
AP-RESET#: GPIO2.38, R31.2, RST1.1
CLK32K: EXT1.8, GPIO2.39
CODEC_AOL: EXT1.10, GPIO4.2
CODEC_AOR: EXT1.12, GPIO4.4
GND: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, C9.1, C10.2, C11.2, C12.1, C13.1, C14.1, C15.1, C16.1, C17.2, C18.2, C19.1, C20.2, C21.2, C22.2, C23.2, C24.2, C25.1, C26.2, C27.2, C28.2, C29.2, C30.2, C31.2, C32.2, C33.2, C34.2, C35.2, C36.2, C37.2, C38.2, C39.1, D3.2, EXT1.2, Flash_Con1.0, Flash_Con1.2, Flash_Con1.6, Flash_Con1.10, Flash_Con1.13, Flash_Con1.14, Flash_Con1.17, Flash_Con1.18, Flash_Con1.22, Flash_Con1.26, Flash_Con1.30, Flash_Con1.34, Flash_Con1.38, GPIO1.2, GPIO1.4, GPIO1.6, GPIO1.8, GPIO2.2, GPIO2.4, GPIO3.2, GPIO3.4, HDMI1.0, HDMI1.2, HDMI1.5, HDMI1.8, HDMI1.11, HDMI1.17, MICRO_SD1.6, MICRO_SD1.10, MICRO_SD1.11, MICRO_SD1.12, MICRO_SD1.13, PWR1.2, PWRLED1.1, PWR_J1.-, R5.1, R8.1, R9.1, R10.1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
GPIO2_B7: EXT1.9, GPIO4.1
GPIO2_C0: EXT1.11, GPIO4.3
GPIO2_C1: EXT1.13, GPIO4.5
GPIO2_C2: EXT1.15, GPIO4.7
GPIO2_C3: EXT1.17, GPIO4.9
GPIO2_C4: EXT1.19, GPIO4.11
GPIO2_C5: EXT1.21, GPIO4.13
GPIO2_C6: EXT1.23, GPIO4.15
I2C1_SCL_PMIC: GPIO2.31, UEXT1.5
I2C1_SDA_PMIC: GPIO2.29, UEXT1.6
unnamed: C1.2, L2.1, USB-HOST1.1
unnamed: C3.2, C5.2, C7.2, L1.2, R7.2, U4.1
unnamed: C4.2, C6.2, C8.2, L2.2, U5.1
unnamed: C14.2, LAN1.5
unnamed: C15.2, LAN1.6
unnamed: C18.1, C26.1, C27.1, L4.1, U9.4, U9.9, U9.44
unnamed: C21.1, C22.1, C23.1, C29.1, C30.1, C31.1, L5.1, U9.14, U9.18, U9.23, U9.26, U9.30, U9.39
unnamed: C24.1, R29.1, R30.1, R31.1, U9.42
unnamed: C32.1, Q1.1, U9.46
unnamed: C33.1, Q1.2, U9.45
unnamed: C34.1, D1.1, VR1.3
unnamed: C38.1, L6.2, MICRO_SD1.4
unnamed: D2.1, UART_DBG1.2
unnamed: FET1.3, HDMI1.13
unnamed: FUSE1.2, HDMI1.18
unnamed: HDMI1.19, R4.1
unnamed: LAN2.KG1, R36.2
unnamed: LAN2.KY1, R35.1
unnamed: MICRO_SD1.5, R40.1
unnamed: PWRLED1.2, R42.2
unnamed: R9.2, U4.3
unnamed: R10.2, U5.3
unnamed: R14.1, U8.3
unnamed: R17.2, R22.1, U9.35
unnamed: R18.2, R19.2, U9.33
unnamed: R20.2, U9.24
unnamed: R21.2, U9.25
unnamed: R23.2, R24.2, U9.41
unnamed: R25.2, R26.2, U9.17
unnamed: R27.2, R28.2, U9.15
unnamed: R32.1, U9.48
unnamed: R33.1, U9.38
unnamed: RM1.1.2, RM2.1.1, U9.32
unnamed: RM1.2.2, RM2.2.1, U9.31
unnamed: RM1.3.2, RM2.3.1, U9.28
unnamed: RM1.4.2, RM2.4.1, U9.27
unnamed: RM3.1.1, U9.22
unnamed: RM3.2.1, U9.21
unnamed: RM3.3.1, U9.20
unnamed: RM3.4.1, U9.19
POWER_ON: GPIO2.40, PWR1.1
UART1_CTSN: EXT1.22, GPIO1.40
UART1_RTSN: EXT1.20, GPIO1.38
UART1_RX: EXT1.18, GPIO1.36, UEXT1.4
UART1_TX: EXT1.16, GPIO1.34, UEXT1.3
VDAC_OUT: EXT1.14, GPIO4.6
VDD_1.8V: Flash_Con1.5, Flash_Con1.7, GPIO3.1, GPIO3.3

## Commit log

2021-05-31 initial upload of CAD files and user manual
2021-05-31 readme update
2021-05-31 fix user manual errors

Notices in the files:
HARDWARE/RK3328-SOM-EVB_Rev-A/RK3328-SOM-EVB_Rev_A.kicad_pcb:
(c)2021
